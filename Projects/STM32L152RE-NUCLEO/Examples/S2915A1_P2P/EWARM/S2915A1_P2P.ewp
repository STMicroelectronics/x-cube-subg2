# IAR project S2915A1_P2P.ewp, settings and files
configuration S2915A1_P2P (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152RE ST STM32L152RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 5
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L152xE
  ICCARM.CCIncludePath2: ../Inc; ../../../../../Drivers/STM32L1xx_HAL_Driver/Inc; ../../../../../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy; ../../../../../Drivers/CMSIS/Device/ST/STM32L1xx/Include; ../../../../../Drivers/CMSIS/Include; ../../../../../Drivers/BSP/Components/S2LP; ../../../../../Drivers/BSP/S2915A1
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: S2915A1_P2P.hex
  ILINK.IlinkOutputFile: S2915A1_P2P.out
  ILINK.IlinkIcfFile: stm32l152xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l152xe.s
  group Application/User
    ../Src/: main.c app_x-cube-subg2.c stm32l1xx_nucleo_bus.c stm32l1xx_nucleo.c stm32l1xx_it.c stm32l1xx_hal_msp.c
  group Drivers/STM32L1xx_HAL_Driver
    ../../../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_spi.c stm32l1xx_hal.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_dma.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_exti.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/S2LP/: s2lp.h s2lp_commands.h s2lp_csma.h s2lp_fifo.h s2lp_gpio.h s2lp_packethandler.h s2lp_pktbasic.h s2lp_pktstack.h s2lp_pktwmbus.h s2lp_qi.h s2lp_radio.h s2lp_regs.h s2lp_timer.h s2lp_types.h s2lp.c s2lp_commands.c s2lp_csma.c s2lp_fifo.c s2lp_gpio.c s2lp_packethandler.c s2lp_pktbasic.c s2lp_pktstack.c s2lp_pktwmbus.c s2lp_qi.c s2lp_radio.c s2lp_timer.c
  group Drivers/BSP/S2915A1
    ../../../../../Drivers/BSP/S2915A1/: s2915a1.h s2915a1.c
