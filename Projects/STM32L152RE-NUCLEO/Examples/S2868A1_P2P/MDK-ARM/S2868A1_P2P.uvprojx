# Keil uVision project S2868A1_P2P.uvprojx, settings and files
target S2868A1_P2P (ARM-ADS)
  device: STM32L152RE STMicroelectronics
  cpu: IRAM(0x20000000-0x20013FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: S2868A1_P2P +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L152xE
  c include: ../Inc;../../../../../Drivers/STM32L1xx_HAL_Driver/Inc;../../../../../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;../../../../../Drivers/CMSIS/Device/ST/STM32L1xx/Include;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/BSP/Components/S2LP;../../../../../Drivers/BSP/S2868A1
  library: MicroLIB
  group Application/MDK-ARM
    ./: startup_stm32l152xe.s
  group Application/User
    ../Src/: main.c app_x-cube-subg2.c stm32l1xx_nucleo_bus.c stm32l1xx_nucleo.c stm32l1xx_it.c stm32l1xx_hal_msp.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/S2LP/: s2lp.c s2lp_commands.c s2lp_csma.c s2lp_fifo.c s2lp_gpio.c s2lp_packethandler.c s2lp_pktbasic.c s2lp_pktstack.c s2lp_pktwmbus.c s2lp_qi.c s2lp_radio.c s2lp_timer.c
  group Drivers/BSP/S2868A1
    ../../../../../Drivers/BSP/S2868A1/: s2868a1.c
  group Drivers/STM32L1xx_HAL_Driver
    ../../../../../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_spi.c stm32l1xx_hal.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_dma.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_exti.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
software components: CMSIS:CORE 4.3.0
