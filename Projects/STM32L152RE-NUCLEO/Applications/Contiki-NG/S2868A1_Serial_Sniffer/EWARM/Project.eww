<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\S2868A1_Serial_Sniffer.ewp</path>
  </project>
  <batchBuild />
</workspace>
