<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\S2868A2_CLI.ewp</path>
  </project>
  <batchBuild />
</workspace>
