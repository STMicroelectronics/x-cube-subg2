<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\S2915A1_Border_Router.ewp</path>
  </project>
  <batchBuild />
</workspace>
