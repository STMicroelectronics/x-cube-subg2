# IAR project S2915A1_Border_Router.ewp, settings and files
configuration S2915A1_Border_Router (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xE
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/Components/S2LP; ../../../../../../Drivers/BSP/S2915A1; ../../../../../../Middlewares/Third_Party/Contiki-NG/os/services; ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/mac/framer; ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/mac/tsch/sixtop; ../../../../../../Middlewares/Third_Party/Contiki-NG/os/services/rpl-border-router; ../../../../../../Middlewares/Third_Party/Contiki-NG/os/dev; ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/mac/csma; ../../../../../../Middlewares/Third_Party/Contiki-NG/os/services/deployment; ../../../../../../Middlewares/Third_Party/Contiki-NG/os/services/shell; ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/mac/tsch; ../../../../../../Middlewares/Third_Party/Contiki-NG/os/lib; ../../../../../../Middlewares/Third_Party/Contiki-NG/os/sys; ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net; ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/mac; ../../../../../../Middlewares/Third_Party/Contiki-NG/os; ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/ipv6; ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/ipv6/multicast; ../../../../../../Middlewares/Third_Party/Contiki-NG/os/services/resolv; ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/routing; ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/routing/rpl-lite; ../../../../../../Middlewares/ST/Contiki-NG_STM32_Library/Inc; ../../../../../../Middlewares/Third_Party/Contiki-NG/os/services/simple-energest
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: S2915A1_Border_Router.hex
  ILINK.IlinkOutputFile: S2915A1_Border_Router.out
  ILINK.IlinkIcfFile: stm32f401xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f401xe.s
  group Application/User
    ../Src/: main.c contiki-platform.c s2lp_interface.c radio-driver.c csma-output.c subg2_contiki_it.c border-router.c httpd-simple.c webserver.c app_contiki-ng.c stm32f4xx_nucleo_bus.c stm32f4xx_nucleo.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/S2LP/: s2lp.h s2lp_commands.h s2lp_csma.h s2lp_fifo.h s2lp_gpio.h s2lp_packethandler.h s2lp_pktbasic.h s2lp_pktstack.h s2lp_pktwmbus.h s2lp_qi.h s2lp_radio.h s2lp_regs.h s2lp_timer.h s2lp_types.h s2lp.c s2lp_commands.c s2lp_csma.c s2lp_fifo.c s2lp_gpio.c s2lp_packethandler.c s2lp_pktbasic.c s2lp_pktstack.c s2lp_pktwmbus.c s2lp_qi.c s2lp_radio.c s2lp_timer.c
  group Drivers/BSP/S2915A1
    ../../../../../../Drivers/BSP/S2915A1/: s2915a1.h s2915a1.c
  group Middlewares/X-CUBE-SUBG2/Network/Contiki-NG/OS_net_mac_framer/framer_802_15_4
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/mac/framer/: frame802154.h frame802154e-ie.h framer-802154.h framer.h frame802154.c frame802154e-ie.c framer-802154.c
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/mac/tsch/sixtop/: sixtop.h sixp-pkt.h
  group Middlewares/X-CUBE-SUBG2/Network/Contiki-NG/OS_border_router_service
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/services/rpl-border-router/: module-macros.h rpl-border-router.h rpl-border-router.c
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/dev/: slip.h slip.c
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/services/rpl-border-router/embedded/: border-router-embedded.c slip-bridge.c
  group Middlewares/X-CUBE-SUBG2/Network/Contiki-NG/OS_net_mac/csma
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/mac/csma/: anti-replay.h ccm-star-packetbuf.h csma-output.h csma-security.h csma.h anti-replay.c ccm-star-packetbuf.c csma-security.c csma.c
  group Middlewares/X-CUBE-SUBG2/Network/Contiki-NG/OS_services
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/services/deployment/: deployment.h module-macros.h
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/services/shell/: module-macros.h serial-shell.h shell-commands.h shell.h serial-shell.c shell-commands.c shell.c
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/services/simple-energest/: simple-energest.h
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/mac/tsch/: tsch.h tsch-adaptive-timesync.h tsch-asn.h tsch-conf.h tsch-const.h tsch-log.h tsch-packet.h tsch-queue.h tsch-rpl.h tsch-schedule.h tsch-security.h tsch-slot-operation.h tsch-stats.h tsch-types.h
  group Middlewares/X-CUBE-SUBG2/Network/Contiki-NG/Core
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/dev/: battery-sensor.h ble-hal.h button-hal.h button-sensor.h eeprom.h gpio-hal.h leds.h nullradio.h radio.h rom.h serial-line.h watchdog.h xmem.h nullradio.c serial-line.c
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/lib/: aes-128.h assert.h ccm-star.h circular-list.h crc16.h dbl-circ-list.h dbl-list.h heapmem.h ifft.h list.h memb.h queue.h random.h ringbuf.h ringbufindex.h sensors.h stack.h trickle-timer.h aes-128.c assert.c ccm-star.c circular-list.c crc16.c dbl-circ-list.c dbl-list.c heapmem.c ifft.c list.c memb.c random.c ringbuf.c ringbufindex.c sensors.c trickle-timer.c
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/sys/: atomic.h autostart.h cc-gcc.h cc.h clock.h compower.h critical.h ctimer.h energest.h etimer.h int-master.h lc-addrlabels.h lc-switch.h lc.h log-conf.h log.h memory-barrier.h mutex.h node-id.h platform.h process.h pt-sem.h pt.h rtimer.h stack-check.h stimer.h subprocess.h timer.h atomic.c autostart.c compower.c ctimer.c energest.c etimer.c log.c mutex.c node-id.c process.c rtimer.c stimer.c timer.c
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/: link-stats.h linkaddr.h nbr-table.h net-debug.h netstack.h packetbuf.h queuebuf.h link-stats.c linkaddr.c nbr-table.c net-debug.c netstack.c packetbuf.c queuebuf.c
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/mac/: llsec802154.h mac-sequence.h mac.h mac-sequence.c mac.c
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/: contiki.h contiki-default-conf.h contiki-lib.h contiki-net.h
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/mac/csma/: csma-security.h
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/mac/tsch/: tsch-conf.h
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/ipv6/: ip64-addr.h tcpip.h uip.h uipbuf.h uip-debug.h uip-ds6.h uip-ds6-nbr.h uip-icmp6.h uip-nd6.h uipopt.h uip-packetqueue.h uip-ds6-route.h uiplib.h
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/ipv6/multicast/: uip-mcast6.h
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/mac/framer/: frame802154.h
  group Middlewares/X-CUBE-SUBG2/Network/Contiki-NG/OS_net_ip/IPv6
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/ipv6/: ip64-addr.h psock.h sicslowpan.h simple-udp.h tcp-socket.h tcpip.h udp-socket.h uip-arch.h uip-debug.h uip-ds6-nbr.h uip-ds6-route.h uip-ds6.h uip-icmp6.h uip-nameserver.h uip-nd6.h uip-packetqueue.h uip-sr.h uip-udp-packet.h uip.h uipbuf.h uiplib.h uipopt.h ip64-addr.c psock.c sicslowpan.c simple-udp.c tcpip.c udp-socket.c uip-ds6-nbr.c uip-ds6-route.c uip-ds6.c uip-icmp6.c uip-nameserver.c uip-nd6.c uip-packetqueue.c uip-sr.c uip-udp-packet.c uip6.c uipbuf.c uiplib.c
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/ipv6/multicast/: esmrf.h roll-tm.h smrf.h uip-mcast6-engines.h uip-mcast6-route.h uip-mcast6-stats.h uip-mcast6.h mpl.h esmrf.c roll-tm.c smrf.c uip-mcast6-route.c uip-mcast6-stats.c
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/services/resolv/: module-macros.h resolv.h resolv.c
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/routing/: routing.h
  group Middlewares/X-CUBE-SUBG2/Network/Contiki-NG/OS_net_routing/rpl-lite
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/routing/rpl-lite/: rpl-conf.h rpl-const.h rpl-dag-root.h rpl-dag.h rpl-ext-header.h rpl-icmp6.h rpl-neighbor.h rpl-timers.h rpl-types.h rpl.h rpl-dag-root.c rpl-dag.c rpl-ext-header.c rpl-icmp6.c rpl-mrhof.c rpl-nbr-policy.c rpl-neighbor.c rpl-of0.c rpl-timers.c rpl.c
  group Middlewares/X-CUBE-SUBG2/Network/Contiki-NG_STM32_Library/Core_dev_leds
    ../../../../../../Middlewares/ST/Contiki-NG_STM32_Library/dev/: leds-arch.c
  group Middlewares/X-CUBE-SUBG2/Network/Contiki-NG_STM32_Library/Core
    ../../../../../../Middlewares/ST/Contiki-NG_STM32_Library/Inc/: console.h ip64-conf.h rtimer-arch.h
    ../../../../../../Middlewares/ST/Contiki-NG_STM32_Library/Src/: clock.c console.c int-master.c rtimer-arch.c slip-arch.c watchdog.c
  group Middlewares/X-CUBE-SUBG2/Network/Contiki-NG_STM32_Library/Core_dev_buttons
    ../../../../../../Middlewares/ST/Contiki-NG_STM32_Library/dev/: button-sensor.c
