# IAR project S2868A1_Border_Router.ewp, settings and files
configuration S2868A1_Border_Router (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xE
  ICCARM.CCIncludePath2: ../Inc; ../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/S2868A1; ../../../../../../Drivers/BSP/Components/S2LP; ../../../../../../Drivers/BSP/Components/S2LP/S2LP_Library/inc; ../../../../../../Middlewares/Third_Party/Contiki-NG/os/services; ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/mac/framer/; ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/mac/tsch/; ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/ipv6/; ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/mac/framer; ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/mac/tsch/sixtop; ../../../../../../Middlewares/Third_Party/Contiki-NG/os/services/rpl-border-router; ../../../../../../Middlewares/Third_Party/Contiki-NG/os/dev; ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/mac/csma; ../../../../../../Middlewares/Third_Party/Contiki-NG/os/services/deployment; ../../../../../../Middlewares/Third_Party/Contiki-NG/os/services/shell; ../../../../../../Middlewares/Third_Party/Contiki-NG/os/services/simple-energest; ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/mac/tsch; ../../../../../../Middlewares/Third_Party/Contiki-NG/os/lib; ../../../../../../Middlewares/Third_Party/Contiki-NG/os/sys; ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net; ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/mac; ../../../../../../Middlewares/Third_Party/Contiki-NG/os; ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/ipv6; ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/ipv6/multicast; ../../../../../../Middlewares/Third_Party/Contiki-NG/os/services/resolv; ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/routing; ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/routing/rpl-lite; ../../../../../../Middlewares/ST/Contiki-NG_STM32_Library/Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: S2868A1_Border_Router.hex
  ILINK.IlinkOutputFile: S2868A1_Border_Router.out
  ILINK.IlinkIcfFile: stm32f401xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f401xe.s
  group Application/User
    ../Src/: main.c s2lp_management.c contiki-platform.c s2lp_interface.c radio-driver.c csma-output.c subg2_contiki_it.c border-router.c httpd-simple.c webserver.c app_contiki-ng.c stm32f4xx_nucleo_bus.c stm32f4xx_nucleo.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/S2LP/: s2lp.c
    ../../../../../../Drivers/BSP/Components/S2LP/S2LP_Library/src/: S2LP_Commands.c S2LP_Csma.c S2LP_Fifo.c S2LP_General.c S2LP_Gpio.c S2LP_PacketHandler.c S2LP_PktBasic.c S2LP_PktStack.c S2LP_PktWMbus.c S2LP_Qi.c S2LP_Radio.c S2LP_Timer.c S2LP_Timer_ex.c S2LP_Types.c
  group Drivers/BSP/S2868A1
    ../../../../../../Drivers/BSP/S2868A1/: s2868a1.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/X-CUBE-SUBG2/Documentation
    ../../../../../../Drivers/BSP/S2868A1/: readme.txt
  group Middlewares/X-CUBE-SUBG2/Network/Contiki-NG/OS_net_mac_framer/framer_802_15_4
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/mac/framer/: frame802154.c frame802154e-ie.c framer-802154.c
  group Middlewares/X-CUBE-SUBG2/Network/Contiki-NG/OS_border_router_service
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/services/rpl-border-router/embedded/: border-router-embedded.c slip-bridge.c
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/services/rpl-border-router/: rpl-border-router.c
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/dev/: slip.c
  group Middlewares/X-CUBE-SUBG2/Network/Contiki-NG/OS_net_mac/csma
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/mac/csma/: anti-replay.c ccm-star-packetbuf.c csma-security.c csma.c
  group Middlewares/X-CUBE-SUBG2/Network/Contiki-NG/OS_services
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/services/shell/: serial-shell.c shell-commands.c shell.c
  group Middlewares/X-CUBE-SUBG2/Network/Contiki-NG/Core
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/dev/: nullradio.c serial-line.c
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/lib/: aes-128.c assert.c ccm-star.c circular-list.c crc16.c dbl-circ-list.c dbl-list.c heapmem.c ifft.c list.c memb.c random.c ringbuf.c ringbufindex.c sensors.c trickle-timer.c
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/sys/: atomic.c autostart.c compower.c ctimer.c energest.c etimer.c log.c mutex.c node-id.c process.c rtimer.c stimer.c timer.c
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/: link-stats.c linkaddr.c nbr-table.c net-debug.c netstack.c packetbuf.c queuebuf.c
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/mac/: mac-sequence.c mac.c
  group Middlewares/X-CUBE-SUBG2/Network/Contiki-NG/OS_net_ip/IPv6
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/ipv6/: ip64-addr.c psock.c sicslowpan.c simple-udp.c tcpip.c udp-socket.c uip-ds6-nbr.c uip-ds6-route.c uip-ds6.c uip-icmp6.c uip-nameserver.c uip-nd6.c uip-packetqueue.c uip-sr.c uip-udp-packet.c uip6.c uipbuf.c uiplib.c
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/ipv6/multicast/: esmrf.c roll-tm.c smrf.c uip-mcast6-route.c uip-mcast6-stats.c
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/services/resolv/: resolv.c
  group Middlewares/X-CUBE-SUBG2/Network/Contiki-NG/OS_net_routing/rpl-lite
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/routing/rpl-lite/: rpl-dag-root.c rpl-dag.c rpl-ext-header.c rpl-icmp6.c rpl-mrhof.c rpl-nbr-policy.c rpl-neighbor.c rpl-of0.c rpl-timers.c rpl.c
  group Middlewares/X-CUBE-SUBG2/Network/Contiki-NG_STM32_Library/Core_dev_leds
    ../../../../../../Middlewares/ST/Contiki-NG_STM32_Library/dev/: leds-arch.c
  group Middlewares/X-CUBE-SUBG2/Network/Contiki-NG_STM32_Library/Core
    ../../../../../../Middlewares/ST/Contiki-NG_STM32_Library/Src/: clock.c console.c int-master.c rtimer-arch.c slip-arch.c watchdog.c
  group Middlewares/X-CUBE-SUBG2/Network/Contiki-NG_STM32_Library/Core_dev_buttons
    ../../../../../../Middlewares/ST/Contiki-NG_STM32_Library/dev/: button-sensor.c
