# IAR project S2868A1_CLI.ewp, settings and files
configuration S2868A1_CLI (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xE
  ICCARM.CCIncludePath2: ../Inc; ../../../../../Drivers/STM32F4xx_HAL_Driver/Inc; ../../../../../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../../../../../Drivers/CMSIS/Include; ../../../../../Drivers/BSP/S2868A1; ../../../../../Drivers/BSP/Components/S2LP; ../../../../../Drivers/BSP/Components/S2LP/S2LP_Library/inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: S2868A1_CLI.hex
  ILINK.IlinkOutputFile: S2868A1_CLI.out
  ILINK.IlinkIcfFile: stm32f401xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f401xe.s
  group Application/User
    ../Src/: main.c s2lp_management.c s2lp_interface_cli.c SDK_UTILS_Time_Measure_Service.c SDK_UTILS_Timers.c command-interpreter2.c crc_lib.c response.c SDK_CLI_commands.c S2LP_CORE_GPIO.c S2LP_CLI_commands.c SDK_EVAL_COM_DMA.c serial_utils.c utils.c app_cli.c stm32f4xx_nucleo_bus.c stm32f4xx_nucleo.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/S2LP/: s2lp.c
    ../../../../../Drivers/BSP/Components/S2LP/S2LP_Library/src/: S2LP_Commands.c S2LP_Csma.c S2LP_Fifo.c S2LP_General.c S2LP_Gpio.c S2LP_PacketHandler.c S2LP_PktBasic.c S2LP_PktStack.c S2LP_PktWMbus.c S2LP_Qi.c S2LP_Radio.c S2LP_Timer.c S2LP_Timer_ex.c S2LP_Types.c
  group Drivers/BSP/S2868A1
    ../../../../../Drivers/BSP/S2868A1/: s2868a1.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/X-CUBE-SUBG2/Documentation
    ../../../../../Drivers/BSP/S2868A1/: readme.txt
