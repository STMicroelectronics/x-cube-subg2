# Keil uVision project S2868A2_Serial_Sniffer.uvprojx, settings and files
target S2868A2_Serial_Sniffer (ARM-ADS)
  device: STM32F401RETx STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: S2868A2_Serial_Sniffer +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F401xE
  c include: ../Inc;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/Components/S2LP;../../../../../../Drivers/BSP/S2868A2;../../../../../../Middlewares/Third_Party/Contiki-NG/os/services;../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/nullnet;../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/mac/framer;../../../../../../Middlewares/Third_Party/Contiki-NG/os/services/deployment;../../../../../../Middlewares/Third_Party/Contiki-NG/os/services/shell;../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/mac/tsch;../../../../../../Middlewares/Third_Party/Contiki-NG/os/dev;../../../../../../Middlewares/Third_Party/Contiki-NG/os/lib;../../../../../../Middlewares/Third_Party/Contiki-NG/os/sys;../../../../../../Middlewares/Third_Party/Contiki-NG/os/net;../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/mac;../../../../../../Middlewares/Third_Party/Contiki-NG/os;../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/mac/csma;../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/ipv6;../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/ipv6/multicast;../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/routing;../../../../../../Middlewares/ST/Contiki-NG_STM32_Library/Inc
  library: MicroLIB
  group Application/MDK-ARM
    ./: startup_stm32f401xe.s
  group Application/User
    ../Src/: main.c contiki-platform.c s2lp_interface.c radio-driver.c subg2_contiki_it.c sniffer.c serial-sniffer.c app_contiki-ng.c stm32f4xx_nucleo_bus.c stm32f4xx_nucleo.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/S2LP/: s2lp.c s2lp_commands.c s2lp_csma.c s2lp_fifo.c s2lp_gpio.c s2lp_packethandler.c s2lp_pktbasic.c s2lp_pktstack.c s2lp_pktwmbus.c s2lp_qi.c s2lp_radio.c s2lp_timer.c
  group Drivers/BSP/S2868A2
    ../../../../../../Drivers/BSP/S2868A2/: s2868a2.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Middlewares/X-CUBE-SUBG2/Network/Contiki-NG/OS_net_ip/Nullnet
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/nullnet/: nullnet.c
  group Middlewares/X-CUBE-SUBG2/Network/Contiki-NG/OS_net_mac_framer/nullframer
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/mac/framer/: nullframer.c
  group Middlewares/X-CUBE-SUBG2/Network/Contiki-NG/OS_services
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/services/shell/: serial-shell.c shell-commands.c shell.c
  group Middlewares/X-CUBE-SUBG2/Network/Contiki-NG/Core
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/dev/: nullradio.c serial-line.c
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/lib/: aes-128.c assert.c ccm-star.c circular-list.c crc16.c dbl-circ-list.c dbl-list.c heapmem.c ifft.c list.c memb.c random.c ringbuf.c ringbufindex.c sensors.c trickle-timer.c
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/sys/: atomic.c autostart.c compower.c ctimer.c energest.c etimer.c log.c mutex.c node-id.c process.c rtimer.c stimer.c timer.c
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/: link-stats.c linkaddr.c nbr-table.c net-debug.c netstack.c packetbuf.c queuebuf.c
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/mac/: mac-sequence.c mac.c
  group Middlewares/X-CUBE-SUBG2/Network/Contiki-NG/OS_net_routing/nullrouting
    ../../../../../../Middlewares/Third_Party/Contiki-NG/os/net/routing/nullrouting/: nullrouting.c
  group Middlewares/X-CUBE-SUBG2/Network/Contiki-NG_STM32_Library/Core_dev_leds
    ../../../../../../Middlewares/ST/Contiki-NG_STM32_Library/dev/: leds-arch.c
  group Middlewares/X-CUBE-SUBG2/Network/Contiki-NG_STM32_Library/Core
    ../../../../../../Middlewares/ST/Contiki-NG_STM32_Library/Src/: clock.c console.c int-master.c rtimer-arch.c slip-arch.c watchdog.c
  group Middlewares/X-CUBE-SUBG2/Network/Contiki-NG_STM32_Library/Core_dev_buttons
    ../../../../../../Middlewares/ST/Contiki-NG_STM32_Library/dev/: button-sensor.c
  group Middlewares/X-CUBE-SUBG2/Network/Contiki-NG_STM32_Library/OS_net_mac/custom
    ../../../../../../Middlewares/ST/Contiki-NG_STM32_Library/Custom/: sniffer-mac.c
software components: CMSIS:CORE 4.3.0
